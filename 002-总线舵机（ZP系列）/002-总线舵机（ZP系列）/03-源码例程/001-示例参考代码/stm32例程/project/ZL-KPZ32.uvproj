# Keil uVision project ZL-KPZ32.uvproj, settings and files
target ZL-Tutorials (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ZL-KPZ32 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\src;..\Libraries\inc;..\user;..\src;..\Libraries\Startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: z_main.c z_setup.c z_loop.c
  group src
    ../src/: z_timer.c z_uart.c z_delay.c z_led.c z_beep.c
  group Libraries
    ../src/: z_stm32f10x_it.c
    ../Libraries/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c
  group CMSIS
    ../Libraries/Startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
